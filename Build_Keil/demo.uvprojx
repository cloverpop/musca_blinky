# Keil uVision project demo.uvprojx, settings and files
target Musca_Demo (6070000::V6.7::.\ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: demo
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3
  c define: FPGA_IMAGE __VTOR_PRESENT=1
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\CMSDK_IoT;..\v2m_mps3;..\apmain;..\apscc
  memory RVCT4: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  link misc: --entry=Reset_Handler
  group MPS3TESTS
    ../apmain/: main.c common.c retarget.c uart_stdout.c font.c
  group CMSIS
    ../cmsis/Device/Source/: CMSDK_driver.c
    ../cmsis/Device/Source/CMSDK_IoT/: system_CMSDK_IoT.c startup_CMSDK_IoT.s
target Simulation_IoT (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MBL") CLOCK(12000000) ELITTLE
  output: simulation_IoT
  c flags: Optim=1 uC99=1
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\selftest_mpb.sct
  link misc: --entry=Reset_Handler
